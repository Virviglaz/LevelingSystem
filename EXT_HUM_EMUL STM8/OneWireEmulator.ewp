# IAR project OneWireEmulator.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; SPL; BMP180; ..\..\..\Libraries\Common; ..\..\..\Libraries\STM8S; ..\..\..\Libraries\STM8S_StdPeriph_Driver\src; ..\..\..\Libraries\STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: OneWireEmulator.srec
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ../../../Libraries/Common/: CRC.c
    ./: interrupt.c main.c
    ../../../Libraries/STM8S/: STM8S_Delays.c
  group GPIO
    ../../../Libraries/STM8S/: STM8_GPIO.c
  group I2C
    ../../../Libraries/Common/: SW_I2C_Driver.c
  group Sensors
    ../../../Libraries/Common/: BME280.c SI7005.c
  group SPL
    ../../../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_gpio.c stm8s_tim2.c stm8s_tim4.c
