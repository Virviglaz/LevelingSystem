# IAR project LevelingSystemSTM8v3.0.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.PreInclude: stm8s_conf.h
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; SPL; MyLIBs
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: LevelingSystemSTM8v3.0.bin
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: comm.c HW.h main.c
  group LIBs
    MyLIBs/: 1-Wire.c CRC.c DS1822.c nrf24l01.c STM8_Delays.c STM8_GPIO.c STM8_SPI.c strings.c
    ./: stm8s_conf.h
  group SPL
    SPL/: stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_itc.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c
